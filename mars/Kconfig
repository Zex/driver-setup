## mars/Kconfig
```kconfig
#
# Mars subsystem configuration
#

menu "Mars support"

config MARS
	tristate "Mars core"
    default y
	help
      The mars module

endmenu
```
